# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -14.88 dB at 1.772 GHz (marker M1); lowest = -94.1 dB at 9.775 GHz (marker M2)
!   lowest |S11| = -37.5 dB at 27.45 GHz (marker M3), VSWR 1.03, Z = 50.7 - j1.14 ohm
!   |S11| at or under -10 dB: 1.599 GHz to 1.993 GHz (393.5 MHz wide, 21.9 % of centre); 17.22 GHz to 17.32 GHz (98.63 MHz wide, 0.571 % of centre); 26.95 GHz to 27.89 GHz (939.7 MHz wide, 3.43 % of centre) (the widest 3 of 7)
!   |S22| runs from -21.8 to -0.3 dB; largest |S21 - S12| = 0.0065
!   the Smith chart shows 25.88 GHz to 28.67 GHz only
!   S11 on the Smith chart (normalised r, x): 25.88 GHz: 0.12, -0.17; 26.46 GHz: 0.23, +0.31; 26.98 GHz: 0.89, +0.55; 27.66 GHz: 0.90, -0.16; 28.22 GHz: 0.30, -0.16; 28.67 GHz: 0.15, +0.12
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.1  -55.6  -50.1  -0.3
! 722.3 MHz  -0.3  -44.5  -44.7  -5.6
! 1.341 GHz  -1.4  -65.4  -68.8  -11.7
! 1.772 GHz  -13.3  -14.9  -14.9  -19.6
! 2.447 GHz  -3.5  -66.0  -65.9  -1.0
! 5.015 GHz  -1.4  -55.6  -55.8  -0.7
! 8.782 GHz  -2.7  -52.5  -52.5  -0.8
! 9.775 GHz  -2.1  -94.1  -76.1  -0.9
! 10 GHz  -2.0  -73.7  -75.0  -0.9
! 15 GHz  -1.8  -63.7  -63.4  -1.2
! 17.16 GHz  -10.2  -23.6  -23.5  -2.7
! 19.99 GHz  -2.7  -58.2  -57.7  -3.3
! 22.09 GHz  -2.0  -31.7  -31.8  -8.0
! 25 GHz  -1.1  -38.7  -38.6  -1.2
! 25.88 GHz  -2.1  -40.2  -40.0  -1.7
! 26.46 GHz  -3.7  -45.0  -45.2  -3.4
! 26.98 GHz  -10.9  -39.4  -39.2  -3.2
! 27.45 GHz  -37.5  -37.5  -37.8  -2.7
! 27.66 GHz  -20.1  -40.9  -41.3  -3.1
! 28.22 GHz  -5.3  -43.0  -42.5  -5.3
! 28.67 GHz  -2.6  -37.8  -37.7  -6.4
! 29.98 GHz  -1.7  -34.9  -35.1  -3.2
