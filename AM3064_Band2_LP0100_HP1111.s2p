# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -17.46 dB at 4.134 GHz (marker M1); lowest = -83.7 dB at 17.25 GHz (marker M2)
!   lowest |S11| = -17.2 dB at 4.209 GHz (marker M3), VSWR 1.32, Z = 59.5 + j11.8 ohm
!   |S11| at or under -10 dB: 3.955 GHz to 4.747 GHz (792 MHz wide, 18.2 % of centre); 12.35 GHz to 12.64 GHz (286.9 MHz wide, 2.3 % of centre); 18.79 GHz to 19.03 GHz (244.1 MHz wide, 1.29 % of centre) (the widest 3 of 5)
!   |S22| runs from -22.0 to -0.2 dB; largest |S21 - S12| = 0.0044
!   the Smith chart shows 3.159 GHz to 5.258 GHz only
!   S11 on the Smith chart (normalised r, x): 3.159 GHz: 0.10, -0.27; 3.553 GHz: 0.16, +0.51; 3.871 GHz: 1.66, +1.47; 4.546 GHz: 1.09, -0.46; 4.902 GHz: 0.90, +1.06; 5.258 GHz: 1.23, -1.56
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.1  -54.8  -47.5  -0.2
! 1.847 GHz  -0.6  -41.7  -41.3  -4.3
! 3.159 GHz  -1.7  -69.4  -68.4  -10.3
! 3.553 GHz  -2.2  -62.5  -59.4  -8.4
! 3.871 GHz  -5.5  -29.5  -29.4  -19.3
! 4.134 GHz  -15.7  -17.5  -17.6  -16.8
! 4.209 GHz  -17.2  -18.2  -18.1  -22.0
! 4.546 GHz  -13.1  -29.0  -29.0  -7.8
! 4.902 GHz  -6.2  -48.6  -48.3  -4.0
! 5.015 GHz  -5.2  -55.6  -56.3  -3.7
! 5.258 GHz  -4.7  -74.4  -62.3  -2.8
! 10 GHz  -3.5  -47.0  -47.4  -1.8
! 11.2 GHz  -3.5  -37.3  -37.1  -2.3
! 15 GHz  -2.6  -54.8  -54.6  -2.0
! 16.37 GHz  -2.1  -54.1  -55.3  -2.2
! 17.25 GHz  -1.5  -83.7  -76.0  -1.3
! 18.21 GHz  -2.6  -53.7  -52.9  -1.7
! 19.99 GHz  -4.3  -46.9  -46.8  -2.2
! 20.87 GHz  -2.5  -65.8  -64.2  -3.1
! 22.9 GHz  -1.6  -45.8  -45.6  -2.5
! 25 GHz  -8.1  -48.7  -48.4  -3.3
! 29.98 GHz  -2.8  -46.8  -45.5  -15.8
