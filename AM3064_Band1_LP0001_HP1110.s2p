# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -11.04 dB at 1.659 GHz (marker M1); lowest = -93.1 dB at 9.532 GHz (marker M2)
!   lowest |S11| = -22.9 dB at 1.772 GHz (marker M3), VSWR 1.15, Z = 57.4 - j1.84 ohm
!   |S11| at or under -10 dB: 1.392 GHz to 1.895 GHz (502.3 MHz wide, 30.6 % of centre); 27.27948 GHz to 27.3511 GHz (71.62 MHz wide, 0.262 % of centre); 27.36 GHz to 27.57 GHz (207 MHz wide, 0.754 % of centre) (the widest 3 of 6)
!   |S22| runs from -22.4 to -0.2 dB; largest |S21 - S12| = 0.0064
!   the Smith chart shows 1.078 GHz to 2.372 GHz only
!   S11 on the Smith chart (normalised r, x): 1.078 GHz: 0.06, +0.10; 1.322 GHz: 0.46, +0.92; 1.641 GHz: 1.11, +0.46; 1.978 GHz: 0.33, +0.20; 2.166 GHz: 0.73, +1.48; 2.372 GHz: 1.63, -2.16
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -50.8  -51.3  -0.2
! 1.078 GHz  -1.0  -65.4  -64.4  -3.9
! 1.322 GHz  -4.2  -58.3  -57.5  -11.3
! 1.641 GHz  -13.3  -11.1  -11.0  -16.0
! 1.659 GHz  -14.5  -11.0  -11.0  -18.4
! 1.772 GHz  -22.9  -13.5  -13.5  -14.8
! 1.978 GHz  -5.6  -34.9  -34.9  -2.9
! 2.166 GHz  -3.6  -58.1  -57.5  -1.4
! 2.372 GHz  -3.6  -70.7  -74.7  -1.0
! 5.015 GHz  -1.5  -55.6  -55.5  -0.7
! 8.782 GHz  -2.7  -50.2  -51.1  -0.8
! 9.532 GHz  -2.4  -93.1  -66.4  -1.0
! 10 GHz  -2.0  -79.1  -68.3  -0.9
! 15 GHz  -2.3  -62.5  -63.0  -1.2
! 17.14 GHz  -9.8  -24.0  -23.9  -2.7
! 19.99 GHz  -2.9  -54.1  -53.9  -3.3
! 20.61 GHz  -1.9  -73.4  -60.2  -4.8
! 21.98 GHz  -1.8  -37.3  -37.4  -9.4
! 25 GHz  -1.3  -37.3  -37.5  -1.1
! 26.87 GHz  -4.7  -63.2  -62.0  -3.2
! 27.47 GHz  -10.4  -39.7  -38.9  -2.7
! 29.98 GHz  -1.7  -35.6  -35.6  -3.2
