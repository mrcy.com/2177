# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -16.51 dB at 1.753 GHz (marker M1); lowest = -109.5 dB at 13.09 GHz (marker M2)
!   lowest |S11| = -37.0 dB at 27.45 GHz (marker M3), VSWR 1.03, Z = 50.6 - j1.28 ohm
!   |S11| at or under -10 dB: 1.6 GHz to 1.973 GHz (372.9 MHz wide, 20.9 % of centre); 17.22 GHz to 17.32 GHz (99.2 MHz wide, 0.574 % of centre); 26.95 GHz to 27.89 GHz (939.7 MHz wide, 3.43 % of centre) (the widest 3 of 7)
!   |S22| runs from -21.3 to -0.2 dB; largest |S21 - S12| = 0.0065
!   the Smith chart shows 25.88 GHz to 28.71 GHz only
!   S11 on the Smith chart (normalised r, x): 25.88 GHz: 0.12, -0.18; 26.48 GHz: 0.24, +0.34; 27 GHz: 0.90, +0.59; 27.68 GHz: 0.86, -0.22; 28.24 GHz: 0.30, -0.11; 28.71 GHz: 0.18, +0.14
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -50.0  -48.1  -0.2
! 1.36 GHz  -1.5  -69.7  -65.5  -9.3
! 1.753 GHz  -13.9  -16.5  -16.5  -17.0
! 2.428 GHz  -3.4  -74.6  -68.5  -0.9
! 5.015 GHz  -1.3  -55.2  -57.0  -0.7
! 8.763 GHz  -2.8  -50.7  -51.0  -1.0
! 10 GHz  -2.0  -71.4  -67.9  -0.9
! 13.09 GHz  -1.9  -109.5  -70.4  -1.0
! 15 GHz  -1.8  -61.5  -64.0  -1.3
! 17.18 GHz  -9.8  -23.6  -23.5  -2.5
! 19.99 GHz  -2.8  -59.8  -59.1  -3.3
! 20.97 GHz  -1.6  -64.7  -73.7  -4.9
! 22.07 GHz  -2.2  -32.0  -32.0  -8.5
! 25 GHz  -1.0  -39.5  -38.5  -1.1
! 25.88 GHz  -2.1  -39.9  -39.7  -1.6
! 26.48 GHz  -3.8  -45.3  -45.4  -3.3
! 27 GHz  -10.5  -39.4  -38.8  -3.4
! 27.45 GHz  -37.0  -37.7  -37.5  -2.7
! 27.68 GHz  -17.1  -41.1  -41.8  -2.8
! 28.24 GHz  -5.3  -41.7  -41.7  -5.4
! 28.71 GHz  -3.0  -37.3  -37.2  -6.4
! 29.98 GHz  -1.8  -35.6  -35.6  -3.2
