# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -13.24 dB at 4.227 GHz (marker M1); lowest = -88.4 dB at 17.18 GHz (marker M2)
!   lowest |S11| = -18.7 dB at 4.284 GHz (marker M3), VSWR 1.26, Z = 61.2 + j6.47 ohm
!   |S11| at or under -10 dB: 3.956 GHz to 4.852 GHz (896.1 MHz wide, 20.3 % of centre); 12.39 GHz to 12.7 GHz (306.8 MHz wide, 2.44 % of centre); 18.79 GHz to 19.03 GHz (243.4 MHz wide, 1.29 % of centre) (the widest 3 of 5)
!   |S22| runs from -24.6 to -0.3 dB; largest |S21 - S12| = 0.0041
!   the Smith chart shows 3.178 GHz to 5.464 GHz only
!   S11 on the Smith chart (normalised r, x): 3.178 GHz: 0.10, -0.23; 3.553 GHz: 0.16, +0.52; 3.89 GHz: 1.86, +1.24; 4.696 GHz: 0.78, -0.17; 5.108 GHz: 2.74, +1.23; 5.464 GHz: 0.50, -0.76
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -53.5  -52.5  -0.3
! 1.922 GHz  -0.5  -41.7  -41.6  -3.9
! 3.178 GHz  -1.6  -78.5  -67.0  -7.9
! 3.553 GHz  -2.2  -59.2  -61.7  -9.2
! 3.89 GHz  -6.3  -25.4  -25.5  -18.4
! 4.227 GHz  -16.2  -13.2  -13.2  -16.7
! 4.284 GHz  -18.7  -13.6  -13.4  -16.8
! 4.696 GHz  -16.2  -23.4  -23.4  -10.3
! 5.015 GHz  -6.1  -38.8  -38.7  -5.2
! 5.108 GHz  -5.3  -43.9  -43.5  -4.0
! 5.464 GHz  -5.3  -63.4  -60.5  -3.2
! 10 GHz  -3.5  -47.3  -47.6  -1.9
! 11.27 GHz  -3.4  -36.5  -36.6  -2.7
! 15 GHz  -2.6  -55.1  -54.4  -1.9
! 16.34 GHz  -2.4  -54.9  -53.8  -2.4
! 17.18 GHz  -1.7  -88.4  -76.9  -1.7
! 18.3 GHz  -2.7  -51.7  -52.1  -2.2
! 19.99 GHz  -4.3  -46.7  -46.6  -2.2
! 20.97 GHz  -2.6  -59.3  -60.1  -2.6
! 23.05 GHz  -1.2  -45.0  -44.9  -2.7
! 25 GHz  -8.1  -49.2  -48.1  -3.3
! 29.98 GHz  -2.7  -45.9  -45.1  -20.2
