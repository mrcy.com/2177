# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -30.88 dB at 4.04 GHz (marker M1); lowest = -87.1 dB at 17.2 GHz (marker M2)
!   lowest |S11| = -20.2 dB at 4.096 GHz (marker M3), VSWR 1.22, Z = 58.7 + j6.04 ohm
!   |S11| at or under -10 dB: 3.961 GHz to 4.229 GHz (268.3 MHz wide, 6.55 % of centre); 4.396 GHz to 4.609 GHz (213 MHz wide, 4.73 % of centre); 18.71 GHz to 19.01 GHz (298.3 MHz wide, 1.58 % of centre) (the widest 3 of 6)
!   |S22| runs from -23.1 to -0.2 dB; largest |S21 - S12| = 0.0032
!   the Smith chart shows 3.14 GHz to 5.033 GHz only
!   S11 on the Smith chart (normalised r, x): 3.14 GHz: 0.10, -0.30; 3.534 GHz: 0.15, +0.46; 3.871 GHz: 1.65, +1.46; 4.359 GHz: 2.05, -0.29; 4.696 GHz: 0.53, +0.44; 5.033 GHz: 4.11, +0.10
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -49.0  -50.3  -0.2
! 1.697 GHz  -0.5  -41.2  -41.3  -5.0
! 3.14 GHz  -1.6  -62.2  -62.3  -11.8
! 3.534 GHz  -2.1  -62.8  -64.2  -11.3
! 3.871 GHz  -5.5  -38.6  -38.6  -19.7
! 4.04 GHz  -14.9  -30.9  -30.8  -13.0
! 4.096 GHz  -20.2  -31.9  -31.7  -10.9
! 4.359 GHz  -9.0  -43.9  -43.8  -4.7
! 4.696 GHz  -7.9  -76.3  -70.2  -3.1
! 5.015 GHz  -4.3  -60.8  -61.7  -2.5
! 5.033 GHz  -4.3  -62.1  -61.6  -2.3
! 10 GHz  -3.4  -47.4  -46.9  -1.7
! 11.09 GHz  -3.7  -39.8  -39.7  -2.0
! 12.32 GHz  -11.3  -64.5  -65.3  -1.6
! 13.15 GHz  -3.3  -49.4  -50.2  -2.0
! 15 GHz  -2.5  -55.2  -55.9  -1.8
! 16.37 GHz  -2.0  -55.2  -54.7  -2.0
! 17.2 GHz  -1.5  -87.1  -80.0  -1.5
! 19.99 GHz  -4.2  -46.6  -46.8  -2.1
! 20.97 GHz  -2.6  -60.2  -60.6  -2.5
! 25 GHz  -8.0  -48.9  -48.8  -3.2
! 29.98 GHz  -2.7  -46.1  -46.0  -17.4
