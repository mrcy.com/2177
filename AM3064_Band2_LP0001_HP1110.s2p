# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -14.81 dB at 3.684 GHz (marker M1); lowest = -85.0 dB at 2.822 GHz (marker M2)
!   lowest |S11| = -19.4 dB at 3.871 GHz (marker M3), VSWR 1.24, Z = 53.8 + j10.5 ohm
!   |S11| at or under -10 dB: 3.514 GHz to 4.444 GHz (930.3 MHz wide, 23.4 % of centre); 18.81 GHz to 19.11 GHz (291.8 MHz wide, 1.54 % of centre); 29.12 GHz to 29.33 GHz (211.8 MHz wide, 0.725 % of centre) (the widest 3 of 6)
!   |S22| runs from -35.5 to -0.2 dB; largest |S21 - S12| = 0.0079
!   the Smith chart shows 2.784 GHz to 4.94 GHz only
!   S11 on the Smith chart (normalised r, x): 2.784 GHz: 0.15, -0.80; 3.14 GHz: 0.15, +0.04; 3.478 GHz: 0.89, +0.81; 4.209 GHz: 1.51, -0.36; 4.583 GHz: 0.56, +0.71; 4.94 GHz: 3.40, -1.31
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.1  -54.1  -44.4  -0.2
! 1.603 GHz  -0.6  -49.0  -49.0  -4.5
! 2.784 GHz  -1.6  -75.4  -91.2  -7.3
! 2.822 GHz  -1.6  -85.0  -68.2  -8.1
! 3.14 GHz  -2.6  -57.6  -55.6  -10.9
! 3.478 GHz  -8.0  -21.4  -21.2  -17.1
! 3.684 GHz  -13.4  -14.8  -14.7  -12.9
! 3.871 GHz  -19.4  -16.2  -16.1  -16.3
! 4.209 GHz  -12.1  -28.4  -28.3  -9.1
! 4.583 GHz  -6.3  -50.9  -51.6  -3.8
! 4.94 GHz  -4.5  -68.5  -70.9  -2.6
! 5.015 GHz  -4.7  -65.6  -66.9  -2.7
! 6.402 GHz  -2.6  -51.9  -52.1  -1.7
! 10 GHz  -3.4  -46.7  -47.3  -1.7
! 15 GHz  -2.7  -54.7  -55.1  -1.9
! 16.97 GHz  -1.6  -76.8  -68.5  -1.5
! 19.99 GHz  -4.4  -46.8  -46.9  -2.1
! 21.12 GHz  -1.7  -59.4  -61.2  -2.6
! 23.16 GHz  -1.0  -44.8  -45.3  -3.0
! 25 GHz  -8.0  -48.7  -48.5  -3.0
! 28.56 GHz  -2.6  -42.8  -43.7  -4.8
! 29.98 GHz  -2.5  -46.2  -46.6  -21.8
