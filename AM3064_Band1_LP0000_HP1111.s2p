# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -18.53 dB at 1.734 GHz (marker M1); lowest = -94.7 dB at 10.92 GHz (marker M2)
!   lowest |S11| = -36.9 dB at 27.45 GHz (marker M3), VSWR 1.03, Z = 50.6 - j1.3 ohm
!   |S11| at or under -10 dB: 1.599 GHz to 1.964 GHz (364.3 MHz wide, 20.5 % of centre); 11.7 GHz to 11.78 GHz (83.51 MHz wide, 0.711 % of centre); 26.95 GHz to 27.89 GHz (939.5 MHz wide, 3.43 % of centre) (the widest 3 of 7)
!   |S22| runs from -20.0 to -0.2 dB; largest |S21 - S12| = 0.0066
!   the Smith chart shows 25.86 GHz to 28.67 GHz only
!   S11 on the Smith chart (normalised r, x): 25.86 GHz: 0.12, -0.19; 26.42 GHz: 0.20, +0.31; 26.96 GHz: 0.83, +0.53; 27.64 GHz: 0.96, -0.14; 28.2 GHz: 0.28, -0.20; 28.67 GHz: 0.15, +0.12
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -63.3  -46.8  -0.2
! 684.8 MHz  -0.3  -44.5  -44.5  -6.1
! 1.36 GHz  -1.5  -67.2  -70.3  -8.6
! 1.734 GHz  -15.2  -18.5  -18.4  -15.6
! 2.353 GHz  -3.5  -72.3  -79.2  -1.0
! 5.015 GHz  -1.5  -56.0  -55.2  -0.8
! 8.745 GHz  -2.7  -50.0  -49.8  -1.1
! 10 GHz  -2.0  -76.0  -70.1  -0.9
! 10.92 GHz  -2.3  -94.7  -80.4  -1.3
! 15 GHz  -1.9  -62.8  -62.9  -1.3
! 17.18 GHz  -9.9  -23.6  -23.6  -2.5
! 19.99 GHz  -2.8  -59.4  -58.3  -3.4
! 22.09 GHz  -2.0  -31.9  -31.9  -7.8
! 25 GHz  -1.0  -38.9  -38.5  -1.1
! 25.86 GHz  -2.0  -40.1  -40.3  -1.8
! 26.42 GHz  -3.2  -44.1  -44.0  -3.4
! 26.96 GHz  -10.6  -39.5  -39.2  -3.3
! 27.45 GHz  -36.9  -37.7  -37.6  -2.7
! 27.64 GHz  -22.8  -40.2  -40.2  -3.3
! 28.2 GHz  -4.9  -42.6  -42.3  -4.6
! 28.67 GHz  -2.6  -37.3  -37.2  -6.4
! 29.98 GHz  -1.6  -35.4  -35.5  -3.2
