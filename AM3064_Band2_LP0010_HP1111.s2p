# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -23.37 dB at 4.059 GHz (marker M1); lowest = -91.0 dB at 17.24 GHz (marker M2)
!   lowest |S11| = -19.3 dB at 4.134 GHz (marker M3), VSWR 1.24, Z = 59.8 + j6.78 ohm
!   |S11| at or under -10 dB: 3.957 GHz to 4.304 GHz (346.1 MHz wide, 8.38 % of centre); 4.402 GHz to 4.648 GHz (245.5 MHz wide, 5.43 % of centre); 18.71 GHz to 19.01 GHz (299.7 MHz wide, 1.59 % of centre) (the widest 3 of 6)
!   |S22| runs from -30.4 to -0.2 dB; largest |S21 - S12| = 0.0025
!   the Smith chart shows 3.14 GHz to 5.108 GHz only
!   S11 on the Smith chart (normalised r, x): 3.14 GHz: 0.10, -0.31; 3.534 GHz: 0.15, +0.45; 3.871 GHz: 1.66, +1.46; 4.415 GHz: 1.73, -0.46; 4.752 GHz: 0.57, +0.55; 5.108 GHz: 3.49, -1.49
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -56.3  -59.9  -0.2
! 1.678 GHz  -0.5  -41.1  -41.0  -4.4
! 3.14 GHz  -1.7  -67.1  -63.1  -12.7
! 3.534 GHz  -2.2  -64.9  -64.0  -8.8
! 3.871 GHz  -5.5  -33.0  -33.0  -15.5
! 4.059 GHz  -14.5  -23.4  -23.5  -19.2
! 4.134 GHz  -19.3  -24.1  -23.9  -17.5
! 4.415 GHz  -10.1  -35.2  -35.2  -6.5
! 4.752 GHz  -7.5  -57.2  -56.8  -3.7
! 5.015 GHz  -4.6  -64.8  -64.3  -2.9
! 5.108 GHz  -4.2  -63.5  -62.1  -2.5
! 10 GHz  -3.4  -47.3  -47.3  -1.8
! 15 GHz  -2.6  -55.4  -54.5  -1.9
! 16.32 GHz  -2.2  -55.1  -54.6  -2.0
! 17.24 GHz  -1.5  -91.0  -75.7  -1.3
! 18.27 GHz  -3.2  -51.7  -52.5  -2.0
! 19.99 GHz  -4.2  -46.9  -46.7  -2.0
! 20.91 GHz  -2.2  -60.1  -62.9  -2.5
! 23.16 GHz  -1.0  -44.7  -45.0  -3.0
! 25 GHz  -8.2  -48.7  -48.9  -3.0
! 28.56 GHz  -3.4  -42.8  -42.8  -4.8
! 29.98 GHz  -2.8  -45.7  -46.4  -19.1
