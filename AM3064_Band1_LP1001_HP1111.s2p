# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -10.67 dB at 1.866 GHz (marker M1); lowest = -98.6 dB at 10.99 GHz (marker M2)
!   lowest |S11| = -37.4 dB at 27.45 GHz (marker M3), VSWR 1.03, Z = 50.7 - j1.15 ohm
!   |S11| at or under -10 dB: 1.6 GHz to 2.088 GHz (488.7 MHz wide, 26.5 % of centre); 17.2 GHz to 17.39 GHz (192.7 MHz wide, 1.11 % of centre); 26.95 GHz to 27.89 GHz (939.4 MHz wide, 3.43 % of centre) (the widest 3 of 6)
!   |S22| runs from -24.8 to -0.3 dB; largest |S21 - S12| = 0.0054
!   the Smith chart shows 25.88 GHz to 28.71 GHz only
!   S11 on the Smith chart (normalised r, x): 25.88 GHz: 0.13, -0.18; 26.48 GHz: 0.24, +0.34; 27.04 GHz: 0.85, +0.52; 27.68 GHz: 0.86, -0.22; 28.24 GHz: 0.30, -0.11; 28.71 GHz: 0.18, +0.14
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -66.7  -55.5  -0.3
! 684.8 MHz  -0.3  -44.1  -44.3  -4.3
! 1.36 GHz  -1.5  -66.7  -67.2  -9.3
! 1.866 GHz  -16.2  -10.7  -10.7  -24.8
! 2.765 GHz  -3.3  -80.3  -67.9  -0.9
! 5.015 GHz  -1.3  -57.7  -57.8  -0.6
! 10 GHz  -2.0  -76.3  -69.7  -0.9
! 10.99 GHz  -2.7  -98.6  -77.1  -1.3
! 15 GHz  -1.8  -63.1  -63.4  -1.4
! 17.25 GHz  -11.1  -25.5  -25.4  -2.1
! 19.99 GHz  -2.8  -59.3  -57.8  -3.0
! 20.93 GHz  -1.4  -71.5  -71.9  -3.6
! 22.13 GHz  -2.7  -30.8  -30.8  -6.5
! 25 GHz  -1.0  -38.7  -38.6  -1.1
! 25.88 GHz  -2.1  -40.2  -39.9  -1.6
! 26.48 GHz  -3.8  -44.6  -45.0  -3.2
! 27.04 GHz  -10.9  -38.5  -37.9  -3.7
! 27.45 GHz  -37.4  -37.6  -37.5  -2.6
! 27.68 GHz  -17.2  -41.0  -40.9  -2.7
! 28.24 GHz  -5.3  -41.7  -41.8  -5.3
! 28.71 GHz  -3.0  -37.1  -37.1  -6.4
! 29.98 GHz  -1.8  -35.4  -35.2  -3.1
