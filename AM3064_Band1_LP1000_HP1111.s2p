# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -11.90 dB at 1.828 GHz (marker M1); lowest = -92.7 dB at 11.11 GHz (marker M2)
!   lowest |S11| = -37.6 dB at 27.45 GHz (marker M3), VSWR 1.03, Z = 50.7 - j1.12 ohm
!   |S11| at or under -10 dB: 1.6 GHz to 2.062 GHz (462.1 MHz wide, 25.2 % of centre); 17.09 GHz to 17.19 GHz (93.3 MHz wide, 0.544 % of centre); 26.95 GHz to 27.89 GHz (938.8 MHz wide, 3.42 % of centre) (the widest 3 of 7)
!   |S22| runs from -24.3 to -0.4 dB; largest |S21 - S12| = 0.0061
!   the Smith chart shows 25.88 GHz to 28.67 GHz only
!   S11 on the Smith chart (normalised r, x): 25.88 GHz: 0.13, -0.17; 26.46 GHz: 0.23, +0.31; 26.98 GHz: 0.89, +0.55; 27.66 GHz: 0.91, -0.16; 28.22 GHz: 0.30, -0.17; 28.67 GHz: 0.15, +0.12
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -60.3  -49.9  -0.4
! 703.5 MHz  -0.3  -44.4  -44.2  -4.9
! 1.36 GHz  -1.5  -66.1  -69.0  -10.8
! 1.828 GHz  -14.1  -11.9  -11.8  -24.3
! 2.634 GHz  -3.7  -68.4  -65.7  -1.0
! 5.015 GHz  -1.5  -55.6  -56.5  -0.6
! 10 GHz  -2.0  -76.5  -72.8  -1.0
! 11.11 GHz  -3.0  -92.7  -76.6  -1.2
! 15 GHz  -1.9  -65.0  -66.9  -1.4
! 17.18 GHz  -10.1  -24.3  -24.2  -2.2
! 19.99 GHz  -2.7  -59.8  -59.5  -3.0
! 20.97 GHz  -1.6  -65.4  -65.9  -4.5
! 22.11 GHz  -2.3  -31.1  -31.0  -7.2
! 25 GHz  -1.1  -39.0  -38.6  -1.1
! 25.88 GHz  -2.1  -40.5  -39.9  -1.6
! 26.46 GHz  -3.6  -45.3  -44.7  -3.4
! 26.98 GHz  -10.8  -39.3  -39.6  -3.1
! 27.45 GHz  -37.6  -37.5  -37.5  -2.7
! 27.66 GHz  -20.2  -40.5  -40.3  -3.0
! 28.22 GHz  -5.3  -41.9  -41.1  -5.2
! 28.67 GHz  -2.6  -37.2  -37.1  -6.3
! 29.98 GHz  -1.6  -35.3  -35.8  -3.2
