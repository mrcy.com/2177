# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -13.18 dB at 1.791 GHz (marker M1); lowest = -109.9 dB at 10.86 GHz (marker M2)
!   lowest |S11| = -37.7 dB at 27.45 GHz (marker M3), VSWR 1.03, Z = 50.7 - j1.12 ohm
!   |S11| at or under -10 dB: 1.599 GHz to 2.012 GHz (412.6 MHz wide, 22.8 % of centre); 17.22 GHz to 17.32 GHz (99.68 MHz wide, 0.577 % of centre); 26.95 GHz to 27.89 GHz (940.3 MHz wide, 3.43 % of centre) (the widest 3 of 7)
!   |S22| runs from -23.9 to -0.3 dB; largest |S21 - S12| = 0.0069
!   the Smith chart shows 25.88 GHz to 28.67 GHz only
!   S11 on the Smith chart (normalised r, x): 25.88 GHz: 0.13, -0.17; 26.48 GHz: 0.25, +0.34; 27.02 GHz: 0.88, +0.58; 27.68 GHz: 0.86, -0.22; 28.22 GHz: 0.31, -0.16; 28.67 GHz: 0.15, +0.12
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -68.8  -54.9  -0.3
! 703.5 MHz  -0.3  -44.3  -44.2  -4.9
! 1.36 GHz  -1.5  -65.0  -70.8  -10.7
! 1.791 GHz  -13.0  -13.2  -13.2  -22.2
! 2.559 GHz  -3.6  -73.9  -80.4  -0.9
! 5.015 GHz  -1.5  -56.8  -56.0  -0.7
! 10 GHz  -2.0  -75.2  -75.9  -0.9
! 10.86 GHz  -2.3  -109.9  -72.6  -1.2
! 15 GHz  -1.9  -62.6  -63.6  -1.3
! 17.18 GHz  -9.9  -23.6  -23.5  -2.4
! 19.99 GHz  -2.8  -56.9  -58.0  -3.3
! 20.91 GHz  -1.4  -73.8  -74.7  -3.8
! 22.09 GHz  -2.0  -31.6  -31.3  -8.0
! 25 GHz  -1.1  -38.9  -39.0  -1.1
! 25.88 GHz  -2.2  -40.1  -40.1  -1.7
! 26.48 GHz  -3.9  -45.1  -44.6  -3.4
! 27.02 GHz  -10.4  -38.4  -38.6  -3.7
! 27.45 GHz  -37.7  -37.4  -37.2  -2.8
! 27.68 GHz  -17.3  -40.5  -40.7  -3.0
! 28.22 GHz  -5.4  -39.7  -39.5  -5.7
! 28.67 GHz  -2.6  -37.0  -36.8  -6.8
! 29.98 GHz  -1.7  -35.6  -35.5  -3.3
