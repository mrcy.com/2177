# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -26.88 dB at 4.059 GHz (marker M1); lowest = -82.6 dB at 17.14 GHz (marker M2)
!   lowest |S11| = -20.0 dB at 4.115 GHz (marker M3), VSWR 1.22, Z = 58.8 + j6.45 ohm
!   |S11| at or under -10 dB: 3.959 GHz to 4.277 GHz (318.1 MHz wide, 7.72 % of centre); 12.28 GHz to 12.5 GHz (213.4 MHz wide, 1.72 % of centre); 18.71 GHz to 19.01 GHz (298.8 MHz wide, 1.58 % of centre) (the widest 3 of 6)
!   |S22| runs from -35.6 to -0.2 dB; largest |S21 - S12| = 0.0017
!   the Smith chart shows 3.14 GHz to 5.071 GHz only
!   S11 on the Smith chart (normalised r, x): 3.14 GHz: 0.09, -0.31; 3.534 GHz: 0.15, +0.45; 3.871 GHz: 1.65, +1.46; 4.396 GHz: 1.76, -0.49; 4.733 GHz: 0.56, +0.55; 5.071 GHz: 3.80, -0.86
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -58.5  -53.4  -0.2
! 1.678 GHz  -0.5  -41.1  -41.1  -4.6
! 3.14 GHz  -1.5  -64.2  -61.6  -12.6
! 3.534 GHz  -2.1  -61.7  -62.7  -9.6
! 3.871 GHz  -5.5  -35.7  -35.6  -16.5
! 4.059 GHz  -15.3  -26.9  -27.0  -16.1
! 4.115 GHz  -20.0  -27.6  -27.7  -13.5
! 4.396 GHz  -9.8  -40.5  -40.0  -5.6
! 4.733 GHz  -7.4  -66.7  -68.1  -3.2
! 5.015 GHz  -4.5  -63.0  -65.1  -2.6
! 5.071 GHz  -4.4  -63.8  -63.5  -2.3
! 10 GHz  -3.4  -47.4  -47.1  -1.8
! 12.29 GHz  -10.1  -60.9  -61.9  -1.6
! 15 GHz  -2.5  -55.3  -54.3  -1.8
! 16.37 GHz  -2.1  -55.4  -54.8  -2.1
! 17.14 GHz  -1.7  -82.6  -72.3  -1.3
! 18.3 GHz  -2.9  -52.3  -52.5  -2.1
! 19.99 GHz  -4.1  -46.5  -46.4  -2.1
! 20.83 GHz  -2.9  -60.5  -66.3  -2.4
! 25 GHz  -8.1  -48.4  -48.2  -3.1
! 28.56 GHz  -3.3  -42.8  -43.5  -4.9
! 29.98 GHz  -2.8  -45.6  -46.9  -21.7
