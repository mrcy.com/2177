# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -11.56 dB at 3.459 GHz (marker M1); lowest = -83.3 dB at 17.12 GHz (marker M2)
!   lowest |S11| = -23.6 dB at 3.703 GHz (marker M3), VSWR 1.14, Z = 53.4 + j5.95 ohm
!   |S11| at or under -10 dB: 3.2 GHz to 4.298 GHz (1.098 GHz wide, 29.3 % of centre); 12.24 GHz to 12.44 GHz (198.1 MHz wide, 1.61 % of centre); 28.91 GHz to 29.08 GHz (164.8 MHz wide, 0.568 % of centre) (the widest 3 of 7)
!   |S22| runs from -23.1 to -0.2 dB; largest |S21 - S12| = 0.0079
!   the Smith chart shows 2.503 GHz to 4.846 GHz only
!   S11 on the Smith chart (normalised r, x): 2.503 GHz: 0.30, -1.54; 2.859 GHz: 0.17, -0.24; 3.178 GHz: 0.67, +0.54; 4.077 GHz: 1.33, -0.35; 4.471 GHz: 0.57, +0.75; 4.846 GHz: 2.79, -1.69
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -58.1  -53.6  -0.2
! 2.503 GHz  -1.5  -67.2  -64.4  -4.7
! 2.859 GHz  -2.8  -51.3  -51.3  -15.4
! 3.178 GHz  -8.9  -17.4  -17.4  -13.7
! 3.459 GHz  -13.4  -11.6  -11.7  -13.7
! 3.703 GHz  -23.6  -13.6  -13.7  -13.4
! 4.077 GHz  -13.8  -25.7  -25.9  -11.5
! 4.471 GHz  -6.1  -49.5  -49.9  -3.8
! 4.846 GHz  -4.5  -72.9  -69.5  -2.6
! 5.015 GHz  -5.1  -69.5  -71.7  -2.4
! 6.308 GHz  -2.3  -52.5  -52.4  -1.6
! 10 GHz  -3.4  -47.2  -47.5  -1.7
! 11.09 GHz  -4.0  -39.4  -39.5  -2.0
! 12.32 GHz  -12.0  -67.5  -66.0  -1.6
! 13.13 GHz  -3.1  -50.1  -49.8  -2.1
! 15 GHz  -2.5  -55.1  -54.9  -1.9
! 17.12 GHz  -1.6  -83.3  -68.0  -1.3
! 19.99 GHz  -4.5  -46.7  -46.3  -2.1
! 20.89 GHz  -2.1  -59.7  -61.6  -2.7
! 23.14 GHz  -1.1  -44.7  -44.0  -3.0
! 25 GHz  -8.1  -49.6  -49.0  -3.2
! 29.98 GHz  -3.1  -47.9  -47.4  -17.3
