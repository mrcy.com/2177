# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -14.92 dB at 4.171 GHz (marker M1); lowest = -98.0 dB at 17.31 GHz (marker M2)
!   lowest |S11| = -18.6 dB at 4.265 GHz (marker M3), VSWR 1.26, Z = 57.8 + j9.99 ohm
!   |S11| at or under -10 dB: 3.956 GHz to 4.79 GHz (833.9 MHz wide, 19.1 % of centre); 12.37 GHz to 12.66 GHz (284.1 MHz wide, 2.27 % of centre); 18.78 GHz to 19.03 GHz (245.2 MHz wide, 1.3 % of centre) (the widest 3 of 5)
!   |S22| runs from -23.2 to -0.2 dB; largest |S21 - S12| = 0.0056
!   the Smith chart shows 3.196 GHz to 5.352 GHz only
!   S11 on the Smith chart (normalised r, x): 3.196 GHz: 0.10, -0.19; 3.571 GHz: 0.15, +0.56; 3.909 GHz: 2.01, +0.92; 4.621 GHz: 0.88, -0.26; 4.996 GHz: 1.31, +1.36; 5.352 GHz: 0.74, -1.22
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -80.2  -54.4  -0.2
! 422.4 MHz  -0.1  -47.2  -47.6  -1.4
! 1.622 GHz  -0.5  -41.0  -40.8  -3.6
! 2.559 GHz  -0.9  -48.8  -48.8  -3.8
! 3.196 GHz  -1.6  -69.6  -68.0  -9.5
! 3.571 GHz  -2.0  -58.8  -60.8  -8.2
! 3.909 GHz  -7.2  -24.5  -24.2  -20.3
! 4.171 GHz  -15.1  -14.9  -15.0  -15.4
! 4.265 GHz  -18.6  -15.5  -15.5  -18.6
! 4.621 GHz  -16.5  -26.0  -26.0  -8.4
! 4.996 GHz  -5.7  -45.4  -45.8  -4.3
! 5.015 GHz  -5.5  -46.6  -46.9  -4.1
! 5.352 GHz  -4.7  -65.4  -63.9  -2.8
! 10 GHz  -3.5  -46.8  -47.1  -1.9
! 11.22 GHz  -3.5  -36.7  -36.6  -2.3
! 15 GHz  -2.7  -54.8  -54.1  -1.9
! 17.31 GHz  -1.7  -98.0  -71.1  -1.4
! 18.29 GHz  -2.9  -52.2  -52.4  -2.2
! 19.99 GHz  -4.3  -46.4  -46.8  -2.2
! 20.89 GHz  -2.3  -60.2  -58.2  -2.9
! 25 GHz  -8.1  -50.0  -49.7  -3.2
! 29.98 GHz  -2.8  -45.4  -45.3  -20.3
