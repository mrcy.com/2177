# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -13.32 dB at 3.759 GHz (marker M1); lowest = -83.1 dB at 2.897 GHz (marker M2)
!   lowest |S11| = -19.8 dB at 3.909 GHz (marker M3), VSWR 1.23, Z = 54.6 + j9.77 ohm
!   |S11| at or under -10 dB: 3.513 GHz to 4.483 GHz (969.9 MHz wide, 24.3 % of centre); 18.81 GHz to 19.1 GHz (292 MHz wide, 1.54 % of centre); 29.12 GHz to 29.33 GHz (211.6 MHz wide, 0.724 % of centre) (the widest 3 of 6)
!   |S22| runs from -30.6 to -0.2 dB; largest |S21 - S12| = 0.0081
!   the Smith chart shows 2.784 GHz to 5.033 GHz only
!   S11 on the Smith chart (normalised r, x): 2.784 GHz: 0.15, -0.80; 3.14 GHz: 0.15, +0.05; 3.478 GHz: 0.90, +0.82; 4.284 GHz: 1.12, -0.43; 5.033 GHz: 1.69, -1.69
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -48.2  -59.6  -0.2
! 1.491 GHz  -0.5  -48.7  -48.2  -3.9
! 2.784 GHz  -1.6  -74.5  -82.2  -6.5
! 2.897 GHz  -1.9  -83.1  -72.8  -8.8
! 3.14 GHz  -2.6  -56.5  -57.0  -12.2
! 3.478 GHz  -8.0  -20.6  -20.7  -16.4
! 3.759 GHz  -13.6  -13.3  -13.5  -13.5
! 3.909 GHz  -19.8  -14.7  -14.7  -15.6
! 4.284 GHz  -13.7  -26.8  -26.7  -10.1
! 5.015 GHz  -4.8  -69.6  -64.4  -3.0
! 5.033 GHz  -4.8  -69.8  -67.1  -2.8
! 6.477 GHz  -2.7  -53.0  -52.6  -1.9
! 10 GHz  -3.5  -47.2  -46.9  -1.7
! 11.07 GHz  -3.6  -38.9  -38.7  -2.1
! 15 GHz  -2.7  -54.6  -55.2  -1.9
! 16.94 GHz  -1.8  -72.4  -70.5  -1.4
! 19.99 GHz  -4.3  -46.7  -46.7  -2.2
! 20.78 GHz  -2.7  -60.5  -57.6  -2.9
! 23.23 GHz  -1.3  -44.4  -44.1  -2.6
! 25 GHz  -8.0  -48.6  -48.9  -3.0
! 28.56 GHz  -2.6  -43.3  -42.7  -4.8
! 29.98 GHz  -2.5  -46.6  -46.5  -19.2
