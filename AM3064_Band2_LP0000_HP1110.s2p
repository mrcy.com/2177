# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -16.52 dB at 3.684 GHz (marker M1); lowest = -89.3 dB at 2.803 GHz (marker M2)
!   lowest |S11| = -19.6 dB at 3.834 GHz (marker M3), VSWR 1.23, Z = 53.9 + j10.2 ohm
!   |S11| at or under -10 dB: 3.513 GHz to 4.395 GHz (882.5 MHz wide, 22.3 % of centre); 18.81 GHz to 19.11 GHz (291.5 MHz wide, 1.54 % of centre); 29.12 GHz to 29.33 GHz (209.9 MHz wide, 0.718 % of centre) (the widest 3 of 6)
!   |S22| runs from -23.1 to -0.2 dB; largest |S21 - S12| = 0.003
!   the Smith chart shows 2.765 GHz to 4.883 GHz only
!   S11 on the Smith chart (normalised r, x): 2.765 GHz: 0.15, -0.87; 3.121 GHz: 0.14, +0.01; 3.459 GHz: 0.76, +0.84; 4.152 GHz: 1.73, -0.31; 4.527 GHz: 0.51, +0.56; 4.883 GHz: 4.09, -0.27
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -53.1  -61.4  -0.2
! 1.622 GHz  -0.5  -49.3  -49.4  -4.9
! 2.765 GHz  -1.5  -73.1  -75.1  -8.0
! 2.803 GHz  -1.6  -89.3  -74.1  -9.1
! 3.121 GHz  -2.5  -57.5  -57.1  -10.5
! 3.459 GHz  -7.0  -23.7  -23.8  -16.4
! 3.684 GHz  -13.4  -16.5  -16.4  -13.2
! 3.834 GHz  -19.6  -18.1  -18.0  -17.2
! 4.152 GHz  -10.8  -30.7  -30.4  -9.1
! 4.527 GHz  -6.7  -54.3  -53.9  -3.6
! 4.883 GHz  -4.3  -66.5  -65.4  -2.5
! 5.015 GHz  -4.8  -68.6  -68.0  -2.5
! 10 GHz  -3.4  -47.3  -47.2  -1.7
! 11.07 GHz  -3.5  -39.8  -39.4  -2.0
! 12.32 GHz  -12.0  -62.0  -65.1  -1.6
! 15 GHz  -2.6  -54.4  -55.1  -1.9
! 16.35 GHz  -2.2  -54.0  -55.4  -2.2
! 16.95 GHz  -1.7  -75.4  -73.2  -1.6
! 19.99 GHz  -4.3  -47.0  -47.3  -2.2
! 20.89 GHz  -2.2  -59.3  -60.0  -2.9
! 25 GHz  -8.0  -50.4  -48.7  -3.1
! 29.98 GHz  -2.5  -46.5  -46.2  -17.3
