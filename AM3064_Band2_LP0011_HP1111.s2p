# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -20.16 dB at 4.115 GHz (marker M1); lowest = -87.4 dB at 17.1 GHz (marker M2)
!   lowest |S11| = -18.3 dB at 4.152 GHz (marker M3), VSWR 1.28, Z = 61.9 + j6.57 ohm
!   |S11| at or under -10 dB: 3.956 GHz to 4.335 GHz (379.3 MHz wide, 9.15 % of centre); 4.375 GHz to 4.7 GHz (324.9 MHz wide, 7.16 % of centre); 18.71 GHz to 19.01 GHz (300 MHz wide, 1.59 % of centre) (the widest 3 of 6)
!   |S22| runs from -44.8 to -0.2 dB; largest |S21 - S12| = 0.0028
!   the Smith chart shows 3.159 GHz to 5.165 GHz only
!   S11 on the Smith chart (normalised r, x): 3.159 GHz: 0.10, -0.27; 3.553 GHz: 0.17, +0.51; 3.871 GHz: 1.66, +1.47; 4.471 GHz: 1.48, -0.53; 4.808 GHz: 0.64, +0.70; 5.165 GHz: 2.63, -1.84
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -49.8  -56.5  -0.2
! 1.734 GHz  -0.5  -41.0  -40.7  -4.2
! 3.159 GHz  -1.6  -65.4  -66.5  -11.6
! 3.553 GHz  -2.3  -62.9  -63.2  -8.2
! 3.871 GHz  -5.5  -30.8  -30.8  -16.3
! 4.115 GHz  -16.3  -20.2  -20.1  -18.6
! 4.152 GHz  -18.3  -20.7  -20.5  -20.3
! 4.471 GHz  -11.0  -32.0  -31.8  -7.0
! 4.808 GHz  -7.0  -51.3  -51.0  -3.7
! 5.015 GHz  -4.9  -72.5  -62.7  -3.2
! 5.165 GHz  -4.4  -63.2  -63.4  -2.7
! 10 GHz  -3.4  -47.2  -47.0  -1.8
! 15 GHz  -2.6  -55.1  -54.3  -1.9
! 16.35 GHz  -2.2  -54.0  -55.2  -2.3
! 17.1 GHz  -1.5  -87.4  -80.6  -1.4
! 18.14 GHz  -3.1  -53.7  -53.8  -1.8
! 19.99 GHz  -4.2  -46.3  -46.8  -2.1
! 20.89 GHz  -2.3  -65.9  -64.3  -2.6
! 23.14 GHz  -1.1  -45.0  -45.0  -2.9
! 25 GHz  -8.1  -49.0  -48.6  -2.9
! 28.56 GHz  -3.4  -43.3  -43.0  -4.7
! 29.98 GHz  -2.7  -46.1  -46.2  -21.7
