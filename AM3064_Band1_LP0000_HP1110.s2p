# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -11.96 dB at 1.622 GHz (marker M1); lowest = -96.8 dB at 9.719 GHz (marker M2)
!   lowest |S11| = -19.5 dB at 1.472 GHz (marker M3), VSWR 1.24, Z = 46.9 + j9.8 ohm
!   |S11| at or under -10 dB: 1.392 GHz to 1.874 GHz (481.6 MHz wide, 29.5 % of centre); 27.27946 GHz to 27.35128 GHz (71.82 MHz wide, 0.263 % of centre); 27.36 GHz to 27.57 GHz (207.5 MHz wide, 0.755 % of centre) (the widest 3 of 6)
!   |S22| runs from -21.7 to -0.2 dB; largest |S21 - S12| = 0.0062
!   the Smith chart shows 947.2 MHz to 2.241 GHz only
!   S11 on the Smith chart (normalised r, x): 947.2 MHz: 0.04, -0.16; 1.247 GHz: 0.17, +0.55; 1.416 GHz: 1.21, +0.37; 1.866 GHz: 0.62, -0.31; 2.053 GHz: 0.36, +0.68; 2.241 GHz: 2.88, +2.23
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.1  -56.7  -51.7  -0.2
! 947.2 MHz  -0.7  -72.5  -72.4  -3.4
! 1.247 GHz  -2.3  -65.4  -71.5  -14.9
! 1.416 GHz  -14.4  -24.9  -24.8  -11.7
! 1.472 GHz  -19.5  -16.3  -16.2  -11.2
! 1.622 GHz  -12.6  -12.0  -11.9  -16.7
! 1.866 GHz  -10.6  -25.7  -25.7  -4.9
! 2.053 GHz  -4.2  -50.1  -49.5  -1.8
! 2.241 GHz  -3.7  -71.5  -69.1  -1.1
! 5.015 GHz  -1.5  -55.4  -55.7  -0.7
! 8.745 GHz  -2.7  -50.4  -50.0  -1.2
! 9.719 GHz  -2.4  -96.8  -70.0  -1.0
! 10 GHz  -2.0  -72.7  -67.7  -0.9
! 15 GHz  -2.3  -63.2  -63.9  -1.3
! 17.16 GHz  -9.6  -23.9  -23.8  -2.7
! 19.99 GHz  -2.8  -55.0  -55.3  -3.3
! 20.98 GHz  -1.3  -70.2  -63.6  -4.8
! 22.02 GHz  -2.4  -37.3  -37.5  -7.8
! 25 GHz  -1.3  -37.4  -37.3  -1.1
! 26.89 GHz  -4.4  -88.2  -84.7  -3.6
! 27.45 GHz  -11.1  -39.5  -39.4  -2.7
! 29.98 GHz  -1.7  -35.7  -35.7  -3.2
