# Hz S DB R 50.0
!freq dBS11 angS11 dBS21 angS21 dBS12 angS12 dBS22 angS22
! Worked out from all points (weakly coupled two-port):
!   1600 points, 10 MHz to 29.98 GHz, reference 50 ohm
!   highest |S21| = -11.99 dB at 3.796 GHz (marker M1); lowest = -88.4 dB at 2.878 GHz (marker M2)
!   lowest |S11| = -20.1 dB at 3.946 GHz (marker M3), VSWR 1.22, Z = 55.8 + j8.72 ohm
!   |S11| at or under -10 dB: 3.515 GHz to 4.527 GHz (1.011 GHz wide, 25.2 % of centre); 12.26 GHz to 12.49 GHz (231.7 MHz wide, 1.87 % of centre); 18.81 GHz to 19.1 GHz (291.4 MHz wide, 1.54 % of centre) (the widest 3 of 6)
!   |S22| runs from -44.1 to -0.3 dB; largest |S21 - S12| = 0.0059
!   the Smith chart shows 2.784 GHz to 5.108 GHz only
!   S11 on the Smith chart (normalised r, x): 2.784 GHz: 0.15, -0.81; 3.14 GHz: 0.15, +0.04; 3.478 GHz: 0.89, +0.80; 4.34 GHz: 1.08, -0.35; 4.733 GHz: 0.91, +1.14; 5.108 GHz: 1.12, -1.49
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -55.2  -50.9  -0.3
! 1.547 GHz  -0.5  -49.0  -48.2  -3.8
! 2.784 GHz  -1.6  -67.4  -69.5  -5.7
! 2.878 GHz  -1.7  -88.4  -78.7  -7.0
! 3.14 GHz  -2.6  -55.6  -58.1  -12.9
! 3.478 GHz  -8.1  -20.2  -20.1  -15.0
! 3.796 GHz  -14.0  -12.0  -11.9  -13.5
! 3.946 GHz  -20.1  -12.9  -12.9  -14.4
! 4.34 GHz  -15.5  -24.3  -24.1  -10.8
! 4.733 GHz  -5.8  -45.8  -45.5  -4.2
! 5.015 GHz  -5.0  -65.8  -65.4  -3.2
! 5.108 GHz  -4.8  -64.9  -74.2  -2.7
! 10 GHz  -3.5  -46.9  -46.8  -1.8
! 11.11 GHz  -3.9  -38.4  -38.3  -2.2
! 15 GHz  -2.7  -54.6  -54.1  -1.9
! 16.97 GHz  -1.6  -71.6  -75.9  -1.4
! 19.99 GHz  -4.3  -46.9  -47.2  -2.1
! 20.95 GHz  -2.4  -57.7  -59.2  -2.2
! 22.9 GHz  -1.6  -45.8  -45.5  -2.4
! 25 GHz  -8.0  -49.1  -49.6  -2.8
! 28.56 GHz  -2.6  -42.9  -42.4  -4.6
! 29.98 GHz  -2.5  -45.4  -45.6  -21.6
